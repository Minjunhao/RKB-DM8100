# IAR project RKB-DM8100.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207xx ST STM32F207xx
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\source\include\; ..\Ethernet\inc\; ..\Libraries\STM32F2x7_ETH_Driver\inc\; ..\Libraries\CMSIS\CM3\CoreSupport\; ..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\; ..\Libraries\STM32F2xx_StdPeriph_Driver\inc\; ..\Utilities\STM32_EVAL\; ..\Utilities\STM32_EVAL\Common\; ..\Utilities\STM32_EVAL\STM322xG_EVAL\; ..\Third_Party\lwip_v1.3.2\src\include\; ..\Third_Party\lwip_v1.3.2\src\include\ipv4\; ..\Third_Party\lwip_v1.3.2\port\STM32F2x7\; ..\Third_Party\lwip_v1.3.2\port\; ..\Third_Party\lwip_v1.3.2\port\STM32F2x7\Standalone\; ..\Third_Party\lwip_v1.3.2\src\include\lwip
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: RKB-DM8100.bin
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: c.srec
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F2xx/: system_stm32f2xx.c
  group EWARM
    ./: startup_stm32f2xx.s
  group LWIP/Api
    ../Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP/Core
    ../Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LWIP/Core/IPV4
    ../Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP/Netif
    ../Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../Third_Party/lwip_v1.3.2/port/STM32F2x7/Standalone/: ethernetif.c
  group LWIP4/Api
    ../Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LWIP4/Core
    ../Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group LWIP4/Core/IPV4
    ../Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LWIP4/Netif
    ../Third_Party/lwip-1.4.1/src/netif/: etharp.c
    ../Third_Party/lwip-1.4.1/port/Standalone/: ethernetif.c
  group STM32F2xx_StdPeriph_Driver
    ../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
    ../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group User
    ../source/: adckey.c ak4114.c ak4117.c command_key.c cortexm3_macro.s eeprom.c fan_ctrl.c i2c.c main.c njw1112.c njw1194.c power_led.c proc_function.c RKB_initmcu.c signal_sense.c stm32f2xx_it.c timer.c uart.c
